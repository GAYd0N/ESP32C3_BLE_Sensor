# Repository GAYd0N/ESP32C3_BLE_Sensor

File README.md:

## 基于Arduino的ESP32-C3-BLE传感控制节点实现

## KiCad design kicad/esp32-c3/esp32-c3.kicad_pcb

Parts:
C1: 100uF; CP_Radial_D6.3mm_P2.50mm
CN1: PZ254V-11-04P; HDR-TH_4P-P2.54-V-M
D2, D3: LED; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
F1: Fuse; Fuse_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R1, R2, R4, R5: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1, U2, U3: ESP32_C3_SuperMini
U5, U6: DHT22; PinHeader_1x03_P2.54mm_Vertical
USB1: TYPE-C 6P(073); TYPE-C-SMD_TYPE-C-6P_5

Connections:
+5V: C1.1, CN1.1, F1.2, U1.5V, U2.5V, U3.5V
/RX: CN1.2, U1.20 (RX/GPIO20)
/TX: CN1.3, U1.21 (TX/GPIO21)
GND: C1.2, CN1.4, D2.1 (K), D3.1 (K), R1.1, R2.2, U1.G (GND), U2.G (GND), U3.G (GND), U5.3 (GND), U6.3 (GND), USB1.7 (SHIELD), USB1.A12 (GND), USB1.B12 (GND)
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: F1.1, USB1.A9 (VBUS), USB1.B9 (VBUS)
unnamed: U2.3.3 (3V3), U5.1 (VDD)
unnamed: U2.10 (GPIO10), U5.2 (DATA)
unnamed: R4.1, U2.8 (SDA/GPIO8)
unnamed: U3.3.3 (3V3), U6.1 (VDD)
unnamed: U3.10 (GPIO10), U6.2 (DATA)
unnamed: R5.1, U3.8 (SDA/GPIO8)
unnamed: R2.1, USB1.A5 (CC1)
unnamed: R1.2, USB1.B5 (CC2)

Notes on the sheet:
ESP32主节点
ESP32子节点
5V电源输入

Board: 2 copper layers, 61.0 x 57.0 mm, 15 parts (0 on the bottom side), 15 nets.

## Commit log

2025-06-11 BLEServer
2025-06-13 BLEClient
2025-06-13 datachunk
2025-06-13 command
2025-06-13 multidevice
2025-06-14 fixcrash
2025-06-14 status
2025-06-14 done
2025-06-27 pack
2025-06-27 Create LICENSE
